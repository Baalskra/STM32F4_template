# IAR project STM32F4_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: CMSIS\Common; CMSIS\STM32F4; Registers\Common; Registers\STM32F4; Registers\STM32F4\Field_values; Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32F4_template.srec
  ILINK.IlinkOutputFile: STM32F4.out
  ILINK.IlinkIcfFile: CMSIS\STM32F4\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS/Common
    CMSIS/Common/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h
  group CMSIS/STM32F4
    CMSIS/STM32F4/: core_cm4.h mpu_armv7.h startup.cpp startup.hpp
  group Registers/Common
    Registers/Common/: AccessModes.hpp Field.hpp FieldValue.hpp Register.hpp Register_common_files.hpp RegisterType.hpp RegisterValue.hpp
  group Registers/STM32F4
    Registers/STM32F4/: FLASH.hpp FLASHBase.hpp GPIOA.hpp GPIOABase.hpp GPIOE.hpp GPIOEBase.hpp MCUs.hpp RCC.hpp RCCBase.hpp SYSCFG.hpp SYSCFGBase.hpp Target.hpp USART1.hpp USART1Base.hpp Voltage.hpp
  group Registers/STM32F4/Field_values
    Registers/STM32F4/Field_values/: common_field_values.hpp flash_field_values.hpp gpio_field_values.hpp rcc_field_values.hpp syscfg_field_values.hpp usart_field_values.hpp
  group Source
    Source/: Button.hpp Clock.hpp global.hpp GPIO.hpp interrupts.cpp Led.hpp main.cpp PinList.hpp
